# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\Device\ST\STM32F4xx\Include; L3GD20_Driver; DevDrive; $PROJ_DIR$; LSM303DLHC_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ./: buton.c main.c
    L3GD20_Driver/: l3gd20.c
    LSM303DLHC_Driver/: lsm303dlhc.c
  group CMSIS
    CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DevDrive
    DevDrive/: ddI2C1.c ddSpi.c ddUsart2.c
